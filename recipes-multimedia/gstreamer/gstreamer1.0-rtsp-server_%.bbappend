# SPDX-License-Identifier: MIT

# Install the example servers (e.g., test-launch) for quick validation.
PACKAGECONFIG:append = " examples"
